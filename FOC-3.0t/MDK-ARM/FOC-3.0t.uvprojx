# Keil uVision project FOC-3.0t.uvprojx, settings and files
target FOC-3.0t (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FOC-3_0t +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;E:/STM32CubeMX/STM32Cube_FW_G4_V1.6.3/Drivers/STM32G4xx_HAL_Driver/Inc;E:/STM32CubeMX/STM32Cube_FW_G4_V1.6.3/Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;E:/STM32CubeMX/STM32Cube_FW_G4_V1.6.3/Drivers/CMSIS/Device/ST/STM32G4xx/Include;E:/STM32CubeMX/STM32Cube_FW_G4_V1.6.3/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    E:/STM32CubeMX/STM32Cube_FW_G4_V1.6.3/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group BSP
    ./: bsp_pwm.c bsp_pwm.h bsp_adc.c bsp_adc.h bsp_encoder.c bsp_encoder.h bsp_led.c bsp_led.h bsp_protect.c bsp_protect.h bsp_config.h bsp_tim.c bsp_tim.h bsp_io.c bsp_io.h
  group FOC
    ./: foc_config.c foc_config.h foc_math.c foc_math.h foc_loop.c foc_loop.h foc_filter.c foc_filter.h foc_state.c foc_state.h foc_svpwm.c foc_svpwm.h
  group APP
    ./: app_motor.c app_motor.h app_filter.c app_filter.h app_vofa.c app_vofa.h
software components: CMSIS:CORE 4.3.0
